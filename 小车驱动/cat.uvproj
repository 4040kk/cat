# Keil uVision project cat.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: cat +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c UR_com.c UR_com.h header.h drive.c UR0_com.c UR0_com.h CSB.h CSB.c ADC.c ADC.h

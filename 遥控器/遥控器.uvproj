# Keil uVision project 遥控器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 遥控器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c UR0_com.c UR0_com.h drive.h drive.c oled.h oled.c oledfont.h bmp.h ADC.h ADC.c UR_com.h UR_com.c

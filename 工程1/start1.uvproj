# Keil uVision project start1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: start1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Time0.h Time0.c STARTUP.A51 shuma.c header.h drive.c main.c KEY.c pm.h LCD1602.c xpt2046.c IR.h ired.h ired.c
